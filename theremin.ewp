# IAR project theremin.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $WS_DIR$\cmsis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: theremin.hex
  ILINK.IlinkOutputFile: theremin.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ./: button.c button.h debug_LED.c debug_led.h encoder.c encoder.h gpio.c gpio.h init.c init.h main.c main.h MCP4921.c MCP4921.h SPI.c SPI.h ther.c timer.c timer.h UART.c UART.h
  group cmsis
    cmsis/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
